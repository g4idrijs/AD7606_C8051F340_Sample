
TIMER2_INIT: 
	MOV TMR2CN,#0
	MOV TMR2RLL,#0E5H
	MOV TMR2RLH,#0BEH
	MOV TMR2L,#0FFH 
	MOV TMR2H,#0FFH
	ORL EIE2,#01H
	ORL TMR2CN,#04H 
RET

T2INTR: 
	PUSH ACC
	ANL TMR2CN,#07FH
	DJNZ COUNT,RETURN
	MOV COUNT,#05H
	MOV A,LED
	MOV P3,A
	MOV DPTR,#P2LED
	MOV A,J
	MOVC A,@A+DPTR 
	MOV P2,A 
	MOV A,LED
	RL A
	ANL A,#0FEH
	MOV LED,A
	INC J
	MOV A,J
	CJNE A,#08H,NOZEROJ
	MOV J,#00H
NOZEROJ:
	DJNZ I,RETURN 
	MOV I,#09H
	MOV LED,#0FFH
RETURN:
	POP ACC
RETI