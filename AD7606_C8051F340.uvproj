# Keil uVision project AD7606_C8051F340.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: AD7606_C8051F340 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: MAIN.c SILABS_STARTUP.A51 USBX_F34X.LIB compiler_defs.h USB_API.h
