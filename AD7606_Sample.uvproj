# Keil uVision project AD7606_Sample.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: AD7606_Sample +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 C8051F340_AD7606.c C8051F340_AD7606.h USB_API.h USB_MAIN.c USBX_F34X.LIB compiler_defs.h Delay.c Delay.h
